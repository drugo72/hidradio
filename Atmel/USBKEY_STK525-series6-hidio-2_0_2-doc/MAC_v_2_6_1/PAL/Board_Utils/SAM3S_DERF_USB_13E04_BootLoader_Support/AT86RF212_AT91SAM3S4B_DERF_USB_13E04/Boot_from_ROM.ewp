# IAR project Boot_from_ROM.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: TAL_TYPE=AT86RF212; PAL_TYPE=AT91SAM3S4B; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=DERF_USB_13E00; HIGHEST_STACK_LAYER=PAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Include; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\boards\DERF_USB_13E00; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\boards\DERF_USB_13E00\Descriptors; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Boot_from_ROM.bin
  ILINK.IlinkOutputFile: Boot_from_ROM.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
