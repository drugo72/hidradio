# IAR project Performance.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: DEBUG=0; FFD; SIO_HUB; USB0; ENABLE_TFA; TAL_TYPE=AT86RF230B; PAL_TYPE=AT90USB1287; PAL_GENERIC_TYPE=AVR; BOARD_TYPE=USBSTICK_C; HIGHEST_STACK_LAYER=TAL; PROMISCUOUS_MODE
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\TFA\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\AVR\Generic\Inc; ..\..\..\..\PAL\AVR\AT90USB1287\Inc; ..\..\..\..\PAL\AVR\AT90USB1287\Boards; ..\..\..\..\PAL\AVR\AT90USB1287\Boards\USBSTICK_C; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgusb1287.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: DEBUG=0; FFD; SIO_HUB; USB0; ENBALE_TFA; TAL_TYPE=AT86RF230B; PAL_TYPE=AT90USB1287; PAL_GENERIC_TYPE=AVR; BOARD_TYPE=USBSTICK_C; HIGHEST_STACK_LAYER=TAL; PROMISCUOUS_MODE
  group (top)
    ../Src/: main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../PAL/AVR/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_utils.c
    ../../../../PAL/AVR/AT90USB1287/Src/: pal_sio_hub.c pal_usb.c
  group PAL/Board
    ../../../../PAL/AVR/AT90USB1287/Boards/USBSTICK_C/: pal_board.c pal_irq.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../TAL/AT86RF230B/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../TFA/AT86RF230B/Src/: tfa.c
