# IAR project Performance.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DEBUG=0; FFD; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB=1; UART3; PAL_USE_SPI_TRX=1; TAL_TYPE=AT86RF212; PAL_TYPE=AT32UC3L064; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=RZ600_212_UC3LEK; HIGHEST_STACK_LAYER=TAL; IEEE_ADDRESS=0xBABE; PROMISCUOUS_MODE
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Boards; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Boards\RZ600_212_UC3LEK; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\..\TFA\Inc; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 1
  ICCAVR32.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../Inc/: app_config.h
    ../../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../../PAL/AVR32/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/AVR32/AT32UC3L064/Boards/RZ600_212_UC3LEK/: pal_board.c pal_config.h pal_irq.c
    ../../../../../PAL/AVR32/AT32UC3L064/Src/: pal_sio_hub.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../../TAL/AT86RF212/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../../TFA/AT86RF212/Src/: tfa.c
