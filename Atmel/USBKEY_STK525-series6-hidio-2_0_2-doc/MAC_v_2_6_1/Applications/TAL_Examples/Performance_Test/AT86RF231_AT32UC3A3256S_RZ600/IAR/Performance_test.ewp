# IAR project Performance_test.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DEBUG=0; FFD; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB=1; USB0; PAL_USE_SPI_TRX=1; TAL_TYPE=AT86RF231; PAL_TYPE=AT32UC3A3256; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=RZ600_231; HIGHEST_STACK_LAYER=TAL; IEEE_ADDRESS=0xBABE; PROMISCUOUS_MODE
  ICCAVR32.CCDiagSuppress: Pa082
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\TFA\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Boards; ..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Boards\RZ600_231; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\..\PAL\AVR32\Libraries\USB\cdc-serial\Inc
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  group Application
    ../../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../../PAL/AVR32/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/AVR32/AT32UC3A3256/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../../PAL/AVR32/AT32UC3A3256/Boards/RZ600_231/: pal_board.c pal_config.h pal_irq.c
  group PAL/USB
    ../../../../../PAL/AVR32/AT32UC3A3256/Src/: pal_usb.c
    ../../../../../PAL/AVR32/Libraries/USB/cdc-serial/Src/: uart_usb_lib.c usb_descriptors.c usb_device_task.c usb_drv.c usb_specific_request.c usb_standard_request.c usb_task.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../../TFA/AT86RF231/Src/: tfa.c
