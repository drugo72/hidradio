# IAR project Performance.ewp, settings and files
configuration Performance (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: NOTRACE; DEBUG=0; FFD; SIO_HUB; UART0; ENABLE_TFA; TAL_TYPE=AT86RF230B; PAL_TYPE=AT91SAM7X256; PAL_GENERIC_TYPE=ARM7; BOARD_TYPE=REB_2_3_REX_ARM_REV_2; HIGHEST_STACK_LAYER=TAL; PROMISCUOUS_MODE
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\TFA\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\ARM7\Generic\Inc; ..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc; ..\..\..\..\PAL\ARM7\AT91SAM7X256\Boards; ..\..\..\..\PAL\ARM7\AT91SAM7X256\Boards\REB_2_3_REX_ARM_REV_2; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc
  OBJCOPY.OOCOutputFile: Performance.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ../Src/: main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../PAL/ARM7/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../PAL/ARM7/AT91SAM7X256/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/ARM7/AT91SAM7X256/Boards/REB_2_3_REX_ARM_REV_2/: pal_board.c pal_irq.c
  group PAL/startup
    ../../../../PAL/ARM7/AT91SAM7X256/Startup/: board_cstartup_iar.s
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../TAL/AT86RF230B/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../TFA/AT86RF230B/Src/: tfa.c
