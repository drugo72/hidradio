# IAR project Performance.ewp, settings and files
configuration Performance (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: TRACE_LEVEL=0; DEBUG=0; NOASSERT; FFD; SIO_HUB; USB0; ENABLE_TFA; TAL_TYPE=AT86RF230B; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_230_SAM3SEK; HIGHEST_STACK_LAYER=TAL; PROMISCUOUS_MODE; IEEE_ADDR=0x123456789ABCDEF0
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\TFA\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_230_SAM3SEK; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_230_SAM3SEK\Descriptors; ..\..\..\..\PAL\SAM3\Libraries\drivers\; ..\..\..\..\PAL\SAM3\Libraries\drivers\pio; ..\..\..\..\PAL\SAM3\Libraries\drivers\utility; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Performance.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group Descriptors
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/Descriptors/: CDCDSerialDriverDescriptors.c
  group PAL
    ../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Lib/cmsis
    ../../../../PAL/SAM3/Libraries/cmsis/: core_cm3.c
  group PAL/Lib/usb/common
    ../../../../PAL/SAM3/Libraries/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../../../PAL/SAM3/Libraries/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
  group PAL/Lib/usb/device
    ../../../../PAL/SAM3/Libraries/usb/device/cdc-serial/: CDCDSerialDriver.c
    ../../../../PAL/SAM3/Libraries/usb/device/core/: USBD.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c
  group PAL/Lib/usb/usbd
    ../../../../PAL/SAM3/Libraries/usb/usbd/: USBD_HAL.c USBDCallbacks_Initialized.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c
  group PAL/startup
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/: board_cstartup_iar.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../TAL/AT86RF230B/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../TFA/AT86RF230B/Src/: tfa.c
