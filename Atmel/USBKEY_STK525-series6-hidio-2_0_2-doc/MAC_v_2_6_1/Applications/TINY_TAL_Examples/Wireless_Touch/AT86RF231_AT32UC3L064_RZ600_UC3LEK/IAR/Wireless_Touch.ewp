# IAR project Wireless_Touch.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DEBUG=0; SIO_HUB; UART3; PAL_USE_SPI_TRX=1; TAL_TYPE=AT86RF231; PAL_TYPE=AVR32UC3L064; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=RZ600_231_UC3LEK; HIGHEST_STACK_LAYER=TINY_TAL; IEEE_ADDRESS=0xBABE; TOUCH_UC3LEK
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\TINY_TAL\Inc; ..\..\..\..\..\TINY_TAL\AT86RF231\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Boards; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Boards\RZ600_231_UC3LEK
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 1
  ICCAVR32.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  group (top)
    ../../Src/: main.c
  group PAL
    ../../../../../PAL/AVR32/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/AVR32/AT32UC3L064/Boards/RZ600_231_UC3LEK/: pal_board.c pal_config.h pal_irq.c
    ../../../../../PAL/AVR32/AT32UC3L064/Src/: pal_sio_hub.c
  group TINY_TAL
    ../../../../../TINY_TAL/AT86RF231/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
  group Touch_Library
    ../../Src/: libuc3l-qtouch-iar.r82
