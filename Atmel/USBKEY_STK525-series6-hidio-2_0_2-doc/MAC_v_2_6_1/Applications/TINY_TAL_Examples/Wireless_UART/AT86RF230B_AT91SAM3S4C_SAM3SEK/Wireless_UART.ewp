# IAR project Wireless_UART.ewp, settings and files
configuration Wireless_UART (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: DEBUG=0; SIO_HUB; USB0; TAL_TYPE=AT86RF230B; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_230_SAM3SEK; HIGHEST_STACK_LAYER=TINY_TAL; IEEE_ADDR=0x123456789ABCDEF0
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Include; ..\..\..\..\TINY_TAL\Inc; ..\..\..\..\TINY_TAL\AT86RF230B\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_230_SAM3SEK; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_230_SAM3SEK\Descriptors; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc
  OBJCOPY.OOCOutputFile: Wireless_UART.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
  group Descriptors
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_231_SAM3SEK/Descriptors/: CDCDSerialDriverDescriptors.c
  group PAL
    ../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Lib/cmsis
    ../../../../PAL/SAM3/Libraries/cmsis/: core_cm3.c
  group PAL/Lib/usb/common
    ../../../../PAL/SAM3/Libraries/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../../../PAL/SAM3/Libraries/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
  group PAL/Lib/usb/device
    ../../../../PAL/SAM3/Libraries/usb/device/cdc-serial/: CDCDSerialDriver.c
    ../../../../PAL/SAM3/Libraries/usb/device/core/: USBD.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c
  group PAL/Lib/usb/usbd
    ../../../../PAL/SAM3/Libraries/usb/usbd/: USBD_HAL.c USBD_LEDs.h USBDCallbacks_Initialized.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c
  group PAL/startup
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/: board_cstartup_iar.c
  group TINY_TAL
    ../../../../TINY_TAL/AT86RF230B/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
