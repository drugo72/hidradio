# IAR project Wireless_UART.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DEBUG=0; SIO_HUB=1; USB0; PAL_USE_SPI_TRX=1; TAL_TYPE=AT86RF231; PAL_TYPE=AT32UC3A3256; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=RZ600_231; HIGHEST_STACK_LAYER=TINY_TAL; IEEE_ADDRESS=0xBABE
  ICCAVR32.CCDiagSuppress: Pa082
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\TINY_TAL\Inc; ..\..\..\..\..\TINY_TAL\AT86RF231\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Boards; ..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Boards\RZ600_231; ..\..\..\..\..\PAL\AVR32\Libraries\USB\cdc-serial\Inc
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 1
  ICCAVR32.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  ICCAVR32.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../Src/: main.c
  group PAL
    ../../../../../PAL/AVR32/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/AVR32/AT32UC3A3256/Src/: pal_sio_hub.c
  group PAL/board
    ../../../../../PAL/AVR32/AT32UC3A3256/Boards/RZ600_231/: pal_board.c pal_config.h pal_irq.c
  group PAL/usb
    ../../../../../PAL/AVR32/AT32UC3A3256/Src/: pal_usb.c
    ../../../../../PAL/AVR32/Libraries/USB/cdc-serial/Src/: uart_usb_lib.c usb_descriptors.c usb_device_task.c usb_drv.c usb_specific_request.c usb_standard_request.c usb_task.c
  group TINY_TAL
    ../../../../../TINY_TAL/AT86RF231/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
