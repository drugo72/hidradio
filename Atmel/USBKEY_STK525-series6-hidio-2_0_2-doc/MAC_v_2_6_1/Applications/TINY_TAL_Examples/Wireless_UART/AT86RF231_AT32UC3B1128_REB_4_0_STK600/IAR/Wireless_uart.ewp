# IAR project Wireless_uart.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DEBUG=0; SIO_HUB=1; UART1; PAL_USE_SPI_TRX=1; TAL_TYPE=AT86RF231; PAL_TYPE=AT32UC3B1128; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=REB_4_0_STK600; HIGHEST_STACK_LAYER=TINY_TAL; IEEE_ADDRESS=0xBABE; UC3B_ONE_CHANNEL; DEF_TOUCH_QMATRIX=0
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\TINY_TAL\Inc; ..\..\..\..\..\TINY_TAL\AT86RF231\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3B1128\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3B1128\Boards; ..\..\..\..\..\PAL\AVR32\AT32UC3B1128\Boards\REB_4_0_STK600
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 1
  ICCAVR32.CCOptStrategy: 0
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3b1128.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../Src/: main.c
  group PAL
    ../../../../../PAL/AVR32/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/AVR32/AT32UC3B1128/Boards/REB_4_0_STK600/: pal_board.c pal_config.h pal_irq.c
    ../../../../../PAL/AVR32/AT32UC3B1128/Src/: pal_sio_hub.c
  group Tiny_TAL
    ../../../../../TINY_TAL/AT86RF231/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
