# IAR project Sensor.ewp, settings and files
configuration Sensor (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: NOTRACE; SIO_HUB; USB0; DEBUG=0; FFD; REDUCED_PARAM_CHECK; TAL_TYPE=AT86RF212; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_212_SAM3SEK; HIGHEST_STACK_LAYER=MAC; SAL_TYPE=AT86RF2xx; ENABLE_TRX_SRAM; STB_ON_SAL; IEEE_ADDR=0x1234567890ABCDEF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\..\PAL\SAM3\Libraries; ..\..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards\RZ600_212_SAM3SEK; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards\RZ600_212_SAM3SEK\Descriptors; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\..\MAC\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\SAL\SW_AES_SAL\Inc; ..\..\..\..\..\SAL\Inc; ..\..\..\..\..\STB\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Sensor.bin
  ILINK.IlinkOutputFile: Sensor.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../Src/: stb_app_defs.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group MAC
    ../../../../../MAC/Src/: mac.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group MAC_API
    ../../../../../MAC/Src/: mac_api.c usr_mcps_data_ind.c usr_mcps_purge_conf.c usr_mlme_associate_ind.c usr_mlme_beacon_notify_ind.c usr_mlme_comm_status_ind.c usr_mlme_disassociate_conf.c usr_mlme_disassociate_ind.c usr_mlme_get_conf.c usr_mlme_orphan_ind.c usr_mlme_poll_conf.c usr_mlme_rx_enable_conf.c usr_mlme_set_conf.c usr_mlme_start_conf.c usr_mlme_sync_loss_ind.c
  group PAL
    ../../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Descriptors
    ../../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/Descriptors/: CDCDSerialDriverDescriptors.c
  group PAL/Libraries/usb/common
    ../../../../../PAL/SAM3/Libraries/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../../../../PAL/SAM3/Libraries/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
  group PAL/Libraries/usb/device
    ../../../../../PAL/SAM3/Libraries/usb/device/cdc-serial/: CDCDSerialDriver.c
    ../../../../../PAL/SAM3/Libraries/usb/device/core/: USBD.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c
  group PAL/Libraries/usb/usbd
    ../../../../../PAL/SAM3/Libraries/usb/usbd/: USBD_HAL.c USBDCallbacks_Initialized.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c
  group PAL/startup
    ../../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: board_cstartup_iar.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../../SAL/AT86RF2xx/Src/: sal.c
  group STB
    ../../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../../TAL/AT86RF212/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
