# IAR project Sensor.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: SIO_HUB; USB0; DEBUG=0; REDUCED_PARAM_CHECK; STB_ON_SAL; TAL_TYPE=AT86RF231; PAL_TYPE=AT32UC3A3256; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=RZ600_231; SAL_TYPE=AT86RF2xx; HIGHEST_STACK_LAYER=MAC; IEEE_ADDRESS=0xBABE; PAL_USE_SPI_TRX=1; ENABLE_TRX_SRAM
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\Inc; ..\..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\..\Include; ..\..\..\..\..\..\MAC\Inc; ..\..\..\..\..\..\TAL\Inc; ..\..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\..\PAL\Inc; ..\..\..\..\..\..\SAL\Inc; ..\..\..\..\..\..\SAL\AT86RF2xx\Inc; ..\..\..\..\..\..\STB\Inc; ..\..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\..\PAL\AVR32\Libraries\USB\cdc-serial\Inc; ..\..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Inc; ..\..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Boards; ..\..\..\..\..\..\PAL\AVR32\AT32UC3A3256\Boards\RZ600_231; ..\..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  ICCAVR32.CCDiagSuppress: Pa082
  XLINK.XclFile: lnk0t.xcl
  group Applications
    ../../Src/: main.c
    ../../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Src/: stb_app_defs.c
    ../../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group MAC
    ../../../../../../MAC/Src/: mac.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_security.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group MAC_API
    ../../../../../../MAC/Src/: mac_api.c usr_mcps_data_ind.c usr_mcps_purge_conf.c usr_mlme_associate_ind.c usr_mlme_beacon_notify_ind.c usr_mlme_comm_status_ind.c usr_mlme_disassociate_conf.c usr_mlme_disassociate_ind.c usr_mlme_get_conf.c usr_mlme_orphan_ind.c usr_mlme_poll_conf.c usr_mlme_rx_enable_conf.c usr_mlme_set_conf.c usr_mlme_start_conf.c usr_mlme_sync_loss_ind.c
  group PAL
    ../../../../../../PAL/AVR32/Generic/Src/: pal.c pal_flash.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../../PAL/AVR32/AT32UC3A3256/Boards/RZ600_231/: pal_board.c pal_config.h pal_irq.c
    ../../../../../../PAL/AVR32/AT32UC3A3256/Src/: pal_sio_hub.c pal_usb.c
  group Resources
    ../../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../../../SAL/AT86RF2xx/Src/: sal.c
  group STB
    ../../../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group USB
    ../../../../../../PAL/AVR32/Libraries/USB/cdc-serial/Src/: uart_usb_lib.c usb_descriptors.c usb_device_task.c usb_drv.c usb_specific_request.c usb_standard_request.c usb_task.c
