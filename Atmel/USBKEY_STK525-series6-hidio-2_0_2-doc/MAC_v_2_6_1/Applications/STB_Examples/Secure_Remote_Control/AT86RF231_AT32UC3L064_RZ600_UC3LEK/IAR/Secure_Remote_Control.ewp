# IAR project Secure_Remote_Control.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: DEBUG=0; SIO_HUB; UART3; STB_ON_SAL; TAL_TYPE=AT86RF231; PAL_TYPE=AT32UC3L064; PAL_GENERIC_TYPE=AVR32; BOARD_TYPE=RZ600_231_UC3LEK; SAL_TYPE=AT86RF2xx; HIGHEST_STACK_LAYER=TAL; IEEE_ADDRESS=0xBABE; PAL_USE_SPI_TRX=1; ENABLE_TRX_SRAM
  ICCAVR32.CCIncludePath2: ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\SAL\Inc; ..\..\..\..\..\SAL\AT86RF2xx\Inc; ..\..\..\..\..\STB\Inc; ..\..\..\..\..\PAL\AVR32\Generic\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Inc; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Boards; ..\..\..\..\..\PAL\AVR32\AT32UC3L064\Boards\RZ600_231_UC3LEK; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  group Application
    ../../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../../PAL/AVR32/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/AVR32/AT32UC3L064/Boards/RZ600_231_UC3LEK/: pal_board.c pal_config.h pal_irq.c
    ../../../../../PAL/AVR32/AT32UC3L064/Src/: pal_sio_hub.c pal_usb.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../../SAL/AT86RF2xx/Src/: sal.c
  group STB
    ../../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
