# IAR project Sensor_Network.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: DEBUG=0; MAC_USER_BUILD_CONFIG; SIO_HUB; USB0; ENABLE_TFA; REDUCED_PARAM_CHECK; TAL_TYPE=AT86RF230B; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_230_SAM3SEK; HIGHEST_STACK_LAYER=MAC; IEEE_ADDR=0x123456789ABCDEF1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_230_SAM3SEK; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_230_SAM3SEK\Descriptors; ..\..\..\..\PAL\SAM3\Libraries\drivers\; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\; ..\..\..\..\MAC\Inc; ..\..\..\..\TAL\Inc; ..\..\..\..\TFA\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\Resources\Buffer_Management\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Sensor_Network.bin
  ILINK.IlinkOutputFile: Sensor_Network.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group MAC
    ../../../../MAC/Src/: mac.c mac_api.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_security.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group PAL
    ../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Descriptors
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/Descriptors/: CDCDSerialDriverDescriptors.c
  group PAL/Lib/usb/common
    ../../../../PAL/SAM3/Libraries/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../../../PAL/SAM3/Libraries/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
  group PAL/Lib/usb/device
    ../../../../PAL/SAM3/Libraries/usb/device/cdc-serial/: CDCDSerialDriver.c
    ../../../../PAL/SAM3/Libraries/usb/device/core/: USBD.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c
  group PAL/Lib/usb/usbd
    ../../../../PAL/SAM3/Libraries/usb/usbd/: USBD_HAL.c USBDCallbacks_Initialized.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c
  group PAL/Startup
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_230_SAM3SEK/: board_cstartup_iar.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../TAL/AT86RF230B/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../TFA/AT86RF230B/Src/: tfa.c
